require optee-opencv.inc


